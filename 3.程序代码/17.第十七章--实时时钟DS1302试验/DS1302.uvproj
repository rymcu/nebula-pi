# Keil uVision project DS1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Drive_1602.c Drive_1602.h Drive_DS1302.c Drive_DS1302.h MainDS1302.c
