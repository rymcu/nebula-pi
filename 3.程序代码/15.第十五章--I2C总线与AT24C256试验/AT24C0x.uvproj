# Keil uVision project AT24C0x.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: AT24C0x +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Drive_1602.c Drive_1602.h Drive_I2C.c Drive_I2C.h Drive_AT24Cxx.c Drive_AT24Cxx.h MainAT24Cxx-01.c
