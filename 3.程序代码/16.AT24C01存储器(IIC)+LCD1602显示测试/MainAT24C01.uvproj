# Keil uVision project MainAT24C01.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MainAT24C01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Drive_AT24C01.c Drive_1602.c Drive_I2C.c Drive_AT24C01.h MainAT24C01.c
