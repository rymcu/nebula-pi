# Keil uVision project WIFI.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: WIFI +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SRC
  group Source Group 1
    ./: bsp_wifi.c bsp_wifi.h main.c bsp_uart.c bsp_uart.h bsp_timer0.c bsp_timer0.h
    ./SRC/: oledfont.h Drive_I2C.c Drive_I2C.h oled.c oled.h
