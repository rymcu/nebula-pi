# Keil uVision project OLED.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: OLED +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\SRC
  group Source Group 1
    ./: main.c Drive_DS18B20.c Drive_DS1302.c Drive_I2C.c Drive_I2C.h Drive_DS1302.h Drive_DS18B20.h AutoDownload.c AutoDownload.h
    ./SRC/: oled.c
