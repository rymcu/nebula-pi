# Keil uVision project Timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Timer
  c flags: SizeSpeed=1
  group Source Group 1
    ./: delay.c
