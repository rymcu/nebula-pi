# Keil uVision project EEPROM.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: EEPROM +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: Drive_Eeprom.c Drive_Eeprom.h EEPROM_Main.c Drive_1602.c Drive_1602.h
