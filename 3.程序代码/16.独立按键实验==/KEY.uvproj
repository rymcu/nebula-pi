# Keil uVision project KEY.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: KEY +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 KEY6.c
