# Keil uVision project Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Microchip
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: Test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Drive_1602.c Drive_1602.h Drive_I2C.c Drive_I2C.h Drive_DS1302.c Drive_DS1302.h Drive_DS18B20.c Drive_DS18B20.h Drive_AT24C01.c Drive_AT24C01.h HongWai.c HongWai.h MainV1-1.c zifu_show.c zifu_show.h Drive_NRF24L01.c Drive_NRF24L01.h
